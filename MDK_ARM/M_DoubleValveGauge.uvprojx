# Keil uVision project M_DoubleValveGauge.uvprojx, settings and files
target DEBUG (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32L402CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M_DoubleValveGauge +hex
  AfterMake: fromelf --bin --output=.\bin\M_DoubleValveGauge.bin .\Objects\M_DoubleValveGauge.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER,DEBUG
  c include: ..\Bsp\inc;..\Driver\n32l40x_std_periph_driver\inc;..\Driver\CMSIS\core;..\Driver\CMSIS\device;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Driver/CMSIS/device/: system_n32l40x.c
    ../Driver/CMSIS/device/startup/: startup_n32l40x.s
  group DRIVER
    ../Driver/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group USER
    ../User/src/: main.c
  group BSP
    ../Bsp/src/: bsp_io.c bsp_timer.c bsp_wdg.c bsp_usart.c bsp_adc.c bsp_spi.c bsp_interrupt.c
  group API
    ../Bsp/api/: api.c
  group 485
    ../Bsp/485/: 485.c protocol.c
  group OLED
    ../Bsp/oled/: oled.c oled_spi.c oled_show.c
  group RADIO
    ../Bsp/radio/: rf.c radio.c cmt2300.c cmt_spi3.c cmt2300_hal.c function.c delay.c
  group MOTOR
    ../Bsp/motor/: motor.c
target RELEASE (6160000::V6.16::ARMCLANG)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: yunliang +hex
  AfterMake: fromelf --bin --output=.\bin\M_DoubleValveGauge.bin .\Objects_Release\M_DoubleValveGauge.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\Bsp\inc;..\Driver\n32l40x_std_periph_driver\inc;..\Driver\CMSIS\core;..\Driver\CMSIS\device;..\User\inc;..\Bsp\oled;..\Bsp\radio;..\Bsp\motor;..\Bsp\485;..\Bsp\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
